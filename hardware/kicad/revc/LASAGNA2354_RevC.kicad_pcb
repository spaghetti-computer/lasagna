# Repository spaghetti-computer/lasagna (continued)

## KiCad design hardware/kicad/revb/NESPICO_RevB.kicad_pcb (continued)

Board: 2 copper layers, 106 parts (0 on the bottom side), 144 nets, no tracks yet.

File hardware/kicad/revb/fab/NESPICO_RevB_BOM_JLCPCB.csv:

Comment,Designator,Footprint,LCSC Part #
10uF,"C1,C2,C3",C_0805_2012Metric,C15850
100nF,"C10,C11,C12,C13,C14,C15,C16,C17,C18,C19,C20,C21,C22,C23,C24,C25",C_0603_1608Metric,C14663
CART_ON,D1,LED_0603_1608Metric,C72043
500mA_PTC,F1,Fuse_1206_3216Metric,C46641012
AO3401A,Q1,SOT-23,C15127
10k,"R1,R10,R11,R12,R13,R14,R15,R16,R17,R18,R19,R2,R20,R21,R22,R23,R24,R25,R26,R27,R28,R29,R3,R30,R31,R32,R33,R34,R35,R36,R37,R38,R39,R4,R40,R41,R42,R43,R44,R45,R5,R6,R7,R8,R9,R93,R94,R95,R96,R97",R_0603_1608Metric,C25804
910,R90,R_0603_1608Metric,C23264
470,R91,R_0603_1608Metric,C23179
220,R92,R_0603_1608Metric,C22962
1k,"R98,R99",R_0603_1608Metric,C21190
SN74AHCT574PWR,"U1,U2,U3,U4,U5",TSSOP-20_4.4x6.5mm_P0.65mm,C129433
74HCT74D,"U10,U11",SOIC-14_3.9x8.7mm_P1.27mm,C686657
74HCT139D,U12,SOIC-16_3.9x9.9mm_P1.27mm,C545677
74AHCT32PW,U13,TSSOP-14_4.4x5mm_P0.65mm,C554656
74HC165D,"U14,U15",SOIC-16_3.9x9.9mm_P1.27mm,C5613
74HC595D,U16,SOIC-16_3.9x9.9mm_P1.27mm,C5947
74LVC245APW,"U6,U7",TSSOP-20_4.4x6.5mm_P0.65mm,C6082
74LVC541APW,U8,TSSOP-20_4.4x6.5mm_P0.65mm,C6093
74HCT04D,U9,SOIC-14_3.9x8.7mm_P1.27mm,C672096
